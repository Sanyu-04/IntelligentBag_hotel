# Keil uVision project project.uvprojx, settings and files
target HT32 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: HT32F52352 Holtek
  pack: Holtek.HT32_DFP.1.0.65
  cpu: IROM(0x00000000-0x0001FDFF) IRAM(0x20000000-0x20003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: HT32 +hex
  AfterMake: fromelf --bin -o "#L.bin" "#L"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F52352_SK, USE_HT32F52342_52, USE_MEM_HT32F52352
  c include: ..\;..\..\library\CMSIS\Include;..\..\library\Device\Holtek\HT32F5xxxx\Include;..\..\library\HT32F5xxxx_Driver\inc;..\..\library\HT32_USBD_Library\inc;..\..\utilities;..\bsp;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM0
  asm define: USE_HT32_CHIP=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1fe00
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --entry Reset_Handler
  group User
    ../: ht32f5xxxx_01_it.c main.c GPIO.c USART1.c SysTick.c USART0.c USART0.h UART0.c UART0.h UART1.c UART1.h
    ../../FreeRTOS/include/: FreeRTOSConfig.h
  group Config
    ./: ht32_op.s HT32F5xxxx_01_DebugSupport.ini
    ../: ht32f5xxxx_conf.h
  group CMSIS
    ../: system_ht32f5xxxx_01.c
  group MDK-ARM
    ./: startup_ht32f5xxxx_01.s
  group Retarget
    ../../library/HT32F5xxxx_Driver/src/: ht32_retarget.c ht32_serial.c
  group Utilities
    ../../utilities/: ht32_board.c
    ../../utilities/common/: i2c_eeprom.c spi_flash.c ebi_lcd.c
  group Library
    ../../library/Ht32F5xxxx_Driver/src/: ht32f5xxxx_adc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_wdt.c ht32_cm0plus_misc.c ht32f5xxxx_crc.c ht32f5xxxx_rtc.c ht32f5xxxx_mctm.c ht32f5xxxx_sci.c ht32f5xxxx_usbd.c ht32f5xxxx_pdma.c ht32f5xxxx_cmp.c ht32f5xxxx_i2s.c ht32f5xxxx_ebi.c
  group bsp
    ../bsp/: LED.c LED.h Delay.h Delay.c FreeRTOS_demo.c WL-125.c WL-125.h usartHMI.c usartHMI.h 4G.c 4G.h ADS1115.c ADS1115.h
  group FreeRTOS/portable
    ../../FreeRTOS/portable/RVDS/ARM_CM0/: port.c portmacro.h
    ../../FreeRTOS/portable/MemMang/: heap_4.c
  group FreeRTOS/source
    ../../FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
software components: Data Exchange:JSON:Jansson 2.7.0
